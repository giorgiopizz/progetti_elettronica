# Keil uVision project seriale_asm.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: seriale_asm
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: start.A51 start1.a51 configurazione.a51
