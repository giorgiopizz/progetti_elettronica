# Keil uVision project led.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: led
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: led.a51 configurazione_micro.asm
