# Keil uVision project c_asm.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: c_asm
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: c8051F020.h C8051F020.inc asm_code.A51 configurazione.asm principale.c
